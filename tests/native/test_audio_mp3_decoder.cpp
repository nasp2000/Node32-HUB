#define DOCTEST_CONFIG_IMPLEMENT_WITH_MAIN
#include "doctest.h"

#include <cstring>

// Compiles the real minimp3 decoder (CC0-1.0) against a known-good single-frame
// MP3 vector from the minimp3 repo (vectors/ILL2_mono.bit). Validates the
// frame-by-frame contract that audio_mp3_decoder.cpp relies on:
//   - mp3dec_decode_frame() reports consumed bytes via frame_bytes
//   - samples, hz, channels come from the frame header
//   - the whole buffer is consumed without infinite loops

#define MINIMP3_IMPLEMENTATION
#include "minimp3.h"

// vectors/ILL2_mono.bit — one valid MPEG-1 Layer 2 mono 48 kHz frame (576 bytes).
static const unsigned char kMonoMp3[576] = {
    0xFF,0xFC,0xA4,0xC0,0x24,0x0B,0x84,0x34,0x32,0x21,0x11,0x12,0x49,0x24,0x92,0x00,
    0x00,0xAA,0xAA,0x2A,0xAA,0xA2,0x20,0xC3,0x8F,0x45,0x14,0x94,0x59,0x36,0x14,0x51,
    0x55,0x95,0x55,0x65,0x95,0x65,0x66,0xD7,0x7F,0xBF,0xDF,0xEF,0x7B,0xDD,0xDD,0x6C,
    0x6D,0xBE,0x7C,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x7F,0xBF,0xDF,0xCF,0x7B,
    0xDD,0xDD,0x6C,0x6D,0xBE,0x7C,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x7F,0x3E,
    0x61,0x4F,0x7C,0x1D,0xDD,0x6C,0x6D,0xBE,0x7C,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,
    0xAD,0xA1,0xBA,0x44,0x32,0x41,0x56,0x36,0x67,0x90,0xB9,0xDF,0x94,0x4E,0x70,0x85,
    0x94,0x7C,0xD8,0x24,0x4F,0x7F,0x70,0x1B,0xD0,0x94,0x25,0x47,0x17,0x0E,0x39,0x2A,
    0x88,0x55,0x90,0x8B,0x54,0xA9,0x18,0x03,0xA0,0xBF,0x24,0xE6,0xB9,0x40,0x2C,0x22,
    0xC8,0x26,0x25,0x21,0x0A,0x12,0x20,0xA2,0x97,0x12,0xBE,0x81,0x4F,0xE2,0x27,0x27,
    0x95,0x90,0xC4,0x6E,0xC0,0x82,0xE3,0x05,0x46,0x2A,0x58,0x42,0x42,0xF6,0x64,0x8D,
    0xFA,0x22,0x42,0x6E,0x5B,0xB9,0xB4,0xA1,0x88,0x26,0x59,0xC4,0x95,0x0A,0xD5,0x68,
    0x41,0x40,0xA0,0x93,0x83,0xD9,0x9D,0x64,0x4D,0xBF,0x7C,0xD4,0xB5,0xAD,0x6B,0x5A,
    0xC6,0xB5,0xCC,0x7F,0x3F,0xDF,0xEF,0x7B,0xDD,0xDD,0x6C,0x6D,0xBE,0x7C,0xD6,0xB5,
    0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x7F,0xBF,0xDF,0xEF,0x7B,0xDD,0xDD,0x6C,0x6D,0xBE,
    0x7C,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x7F,0xBF,0xDF,0xEF,0x7B,0xDD,0xDD,
    0x6C,0x6D,0xBE,0x7C,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x81,0x30,0x00,0x76,
    0x90,0x82,0x21,0x10,0xCD,0x10,0xCC,0x88,0x88,0x88,0x44,0x44,0x44,0x92,0x49,0x24,
    0x92,0x49,0x24,0x90,0x00,0x00,0x00,0x02,0xBA,0x20,0xAE,0x02,0x22,0xA0,0x02,0x0A,
    0x00,0x88,0x0A,0x02,0x88,0x28,0x80,0x42,0xD0,0x28,0x93,0xD4,0x39,0x12,0xD5,0x45,
    0x55,0x91,0x50,0xC4,0x98,0x4C,0xE5,0xD3,0x5D,0x85,0x17,0x48,0xF4,0xD4,0x61,0x56,
    0x10,0x65,0x56,0x56,0x45,0x66,0x56,0x6D,0x34,0x16,0x69,0x66,0x99,0x59,0xC5,0x11,
    0x55,0x76,0x56,0x71,0x54,0x56,0x61,0x75,0x11,0x61,0xB6,0x1C,0x69,0x77,0x55,0x49,
    0xA6,0x1A,0x5D,0xD4,0xDC,0x61,0xC6,0xD8,0x79,0x64,0x96,0x61,0x95,0x93,0x61,0xC6,
    0x1C,0x71,0x97,0x53,0x61,0xD6,0x5C,0x4D,0xD6,0x5D,0x79,0x97,0x15,0x65,0xF6,0x5C,
    0x51,0xD6,0x9D,0x7D,0x97,0x1F,0xEF,0xF7,0xFB,0xFD,0xFE,0xFF,0x7F,0xBF,0xDF,0xEF,
    0x7B,0xDE,0xF7,0xBD,0xEF,0x7B,0xDE,0xEE,0xEE,0xEE,0xEE,0xEB,0x62,0xD8,0xDB,0x6D,
    0xB6,0xDF,0x3E,0x7C,0xF9,0xF3,0xE7,0xCF,0x9F,0x3E,0x6B,0x5A,0xD6,0xB5,0xAD,0x6B,
    0x5A,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x6B,0x5A,
    0xFF,0x7F,0xBF,0xDF,0xEF,0xF7,0xFB,0xFD,0xFE,0xFE,0x7B,0xDE,0xF7,0xBD,0xEF,0x7B,
    0xDE,0xF7,0x77,0x77,0x77,0x77,0x5B,0x16,0xC6,0xDB,0x6D,0xB6,0xF9,0xF3,0xE7,0xCF,
    0x9F,0x3E,0x7C,0xF9,0xF3,0x5A,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x6B,0x5A,
    0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x6B,0x5A,0xD7,0xEB,0xFD,0xF0,0xFF,0x7F,
    0x3E,0x60,0x0F,0x78,0x13,0xDC,0xF7,0xBD,0xEE,0x83,0x1E,0xF7,0xBB,0xB3,0xBC,0x3B,
    0xBA,0xD8,0x8D,0xB6,0xDB,0x6D,0xB7,0xCF,0x9F,0x3E,0x7C,0xF9,0xF3,0xE7,0xCF,0x9A,
    0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x6B,0x5A,0xD6,0xB5,0xAD,0x6B,0x00,0x00
};

TEST_CASE("minimp3 decodes the known mono frame correctly") {
    mp3dec_t dec;
    mp3dec_init(&dec);
    short pcm[MINIMP3_MAX_SAMPLES_PER_FRAME];

    mp3dec_frame_info_t info;
    memset(&info, 0, sizeof(info));
    int samples = mp3dec_decode_frame(&dec, kMonoMp3, sizeof(kMonoMp3), pcm, &info);

    CHECK(samples == 1152);
    CHECK(info.hz == 48000);
    CHECK(info.channels == 1);
    CHECK(info.frame_bytes == 576);
    CHECK(info.layer == 2);
}

TEST_CASE("minimp3 consumes the entire single-frame buffer") {
    mp3dec_t dec;
    mp3dec_init(&dec);
    short pcm[MINIMP3_MAX_SAMPLES_PER_FRAME];

    unsigned long pos = 0;
    unsigned long consumed = 0;
    unsigned long frames = 0;
    unsigned long totalSamples = 0;
    while (pos < sizeof(kMonoMp3)) {
        mp3dec_frame_info_t info;
        memset(&info, 0, sizeof(info));
        int s = mp3dec_decode_frame(&dec, kMonoMp3 + pos, sizeof(kMonoMp3) - pos, pcm, &info);
        if (info.frame_bytes <= 0) { pos++; continue; } // skip sync gap (none expected here)
        consumed += (unsigned long)info.frame_bytes;
        pos += (unsigned long)info.frame_bytes;
        if (s > 0) { frames++; totalSamples += (unsigned long)s; }
    }
    CHECK(frames == 1);
    CHECK(totalSamples == 1152);
    CHECK(consumed == sizeof(kMonoMp3));
}

TEST_CASE("minimp3 skips leading garbage before syncing (ID3-like bytes)") {
    unsigned char buf[576 + 16];
    buf[0] = 0x00; // garbage byte before the frame
    memcpy(buf + 1, kMonoMp3, sizeof(kMonoMp3));

    mp3dec_t dec;
    mp3dec_init(&dec);
    short pcm[MINIMP3_MAX_SAMPLES_PER_FRAME];
    mp3dec_frame_info_t info;
    memset(&info, 0, sizeof(info));

    // Feed with a small lookahead; decoder must skip the garbage and lock on.
    (void)mp3dec_decode_frame(&dec, buf, 128, pcm, &info);
    // First call may return 0 (garbage consumed, frame_bytes>0) or the frame.
    bool progressed = (info.frame_bytes > 0);
    CHECK(progressed);
}

TEST_CASE("minimp3 partial buffer returns zero samples but consumes the bytes") {
    mp3dec_t dec;
    mp3dec_init(&dec);
    short pcm[MINIMP3_MAX_SAMPLES_PER_FRAME];
    mp3dec_frame_info_t info;
    memset(&info, 0, sizeof(info));

    // Too little data to decode a frame: 0 samples, but the decoder consumed
    // the available bytes (frame_bytes == input length) and waits for more.
    int samples = mp3dec_decode_frame(&dec, kMonoMp3, 4, pcm, &info);
    CHECK(samples == 0);
    CHECK(info.frame_bytes == 4);
}
